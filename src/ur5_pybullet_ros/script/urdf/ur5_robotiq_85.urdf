Commit message: ros_pack, rviz display error

File: src/ur5_pybullet_ros/script/urdf/ur5_robotiq_85.urdf (robot description, URDF)
Before this commit: robot ur5_robotiq_85, 20 links, 19 joints
Links:
- link ee_link: mass None -> 0.01
