Commit message: better table model(with legs)

File: src/ur5_pybullet_ros/script/urdf/objects/table/table.urdf (robot description, URDF)
Before this commit: robot table.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=0.1 0.1 0.58; collision box size=0.1 0.1 0.58
