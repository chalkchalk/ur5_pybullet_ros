Commit message: building moveit interface

File: src/ur5_moveit/config/gazebo_ur5_robotiq_85.urdf (robot description, URDF)
Before this commit: robot ur5_robotiq_85, 20 links, 19 joints
Joints:
- joint world_arm_joint: origin xyz=0 0 0 rpy=0.0 0.0 0 -> xyz=0 0 0.5 rpy=0.0 0.0 0
